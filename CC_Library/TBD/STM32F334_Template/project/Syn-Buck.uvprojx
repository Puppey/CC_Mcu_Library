# Keil uVision project Syn-Buck.uvprojx, settings and files
target stm32f334 (ARM-ADS)
  device: STM32F334C6 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Syn-Buck current-mode  control
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F334x8,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\api;..\cm4_core;..\fwlib\inc;..\driver;..\main;..\alg;..\DPlib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  scatter file: .\Objects\f334 DEMO.sct
  group main
    ../main/: main.c stm32f3xx_it.c system_stm32f30x.c
  group api
    ../api/: oled.c
  group DPlib
    ../DPlib/: DPlib.c
  group alg
    ../alg/: hp_pid_code.c
  group driver
    ../driver/: onboard_led.c usart.c hrpwm.c adc.c virtual_i2c.c timer.c
  group fwlib
    ../fwlib/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group cm4_core
    ../cm4_core/: startup_stm32f334x8.s
